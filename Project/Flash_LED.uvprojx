# Keil uVision project Flash_LED.uvprojx, settings and files
target Flash LED (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Flash_LED +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, VECT_TAB_FLASH, DEBUGGING
  c include: ..\Project;.\Applications;.\Status;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ST_FWlib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group Status
    ./Status/: LEDFlash.c
  group Application
    ./Applications/: main.c
  group Information
    ./: Project_Details.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.0.0
